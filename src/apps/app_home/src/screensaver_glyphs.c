#include "screensaver_glyphs.h"

#include <stddef.h>

typedef struct {
    char ch;
    uint8_t rows[7];
} glyph_t;

/* Entry 0 MUST be the space glyph: ss_glyph_rows() returns it for any miss. */
static const glyph_t s_glyphs[] = {
    {' ', {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}},
    {'-', {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}},
    {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C}},
    {':', {0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00}},
    {'0', {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}},
    {'1', {0x04, 0x0C, 0x14, 0x04, 0x04, 0x04, 0x1F}},
    {'2', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}},
    {'3', {0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E}},
    {'4', {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}},
    {'5', {0x1F, 0x10, 0x10, 0x1E, 0x01, 0x01, 0x1E}},
    {'6', {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E}},
    {'7', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}},
    {'9', {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x1C}},
    {'A', {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'C', {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}},
    {'F', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}},
    {'H', {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'I', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1F}},
    {'M', {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}},
    {'P', {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}},
    {'R', {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}},
    {'S', {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}},
    {'T', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}},
    {'X', {0x11, 0x0A, 0x04, 0x04, 0x04, 0x0A, 0x11}},

    /* Density ramp + symbols used by plasma / matrix / rain / sine. */
    {'=', {0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00}},
    {'+', {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00}},
    {'*', {0x00, 0x15, 0x0E, 0x1F, 0x0E, 0x15, 0x00}},
    {'#', {0x0A, 0x0A, 0x1F, 0x0A, 0x1F, 0x0A, 0x0A}},
    {'%', {0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03}},
    {'@', {0x0E, 0x11, 0x17, 0x15, 0x17, 0x10, 0x0E}},
    {'<', {0x02, 0x04, 0x08, 0x10, 0x08, 0x04, 0x02}},
    {'>', {0x08, 0x04, 0x02, 0x01, 0x02, 0x04, 0x08}},
    {'/', {0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10}},
    {'$', {0x04, 0x0F, 0x14, 0x0E, 0x05, 0x1E, 0x04}},
    {'&', {0x0C, 0x12, 0x14, 0x08, 0x15, 0x12, 0x0D}},
    {'~', {0x00, 0x00, 0x08, 0x15, 0x02, 0x00, 0x00}},

    /* Box-drawing for pipes (keyed by SS_GLYPH_PIPE_* byte codes). */
    {(char)SS_GLYPH_PIPE_H, {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}},
    {(char)SS_GLYPH_PIPE_V, {0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {(char)SS_GLYPH_PIPE_TL, {0x00, 0x00, 0x00, 0x07, 0x04, 0x04, 0x04}},
    {(char)SS_GLYPH_PIPE_TR, {0x00, 0x00, 0x00, 0x1C, 0x04, 0x04, 0x04}},
    {(char)SS_GLYPH_PIPE_BL, {0x04, 0x04, 0x04, 0x07, 0x00, 0x00, 0x00}},
    {(char)SS_GLYPH_PIPE_BR, {0x04, 0x04, 0x04, 0x1C, 0x00, 0x00, 0x00}},
};

const uint8_t *ss_glyph_rows(char c)
{
    for (size_t i = 0; i < sizeof(s_glyphs) / sizeof(s_glyphs[0]); i++) {
        if (s_glyphs[i].ch == c) {
            return s_glyphs[i].rows;
        }
    }

    return s_glyphs[0].rows;
}

void ss_glyph_draw_char(pixel_writer_t writer, void *ctx, int32_t x, int32_t y, int32_t scale,
                        char ch, uint16_t color)
{
    const uint8_t *rows = ss_glyph_rows(ch);

    for (int32_t row = 0; row < 7; row++) {
        for (int32_t col = 0; col < 5; col++) {
            if ((rows[row] & (1U << (4 - col))) == 0) {
                continue;
            }

            for (int32_t dy = 0; dy < scale; dy++) {
                for (int32_t dx = 0; dx < scale; dx++) {
                    writer(ctx, x + col * scale + dx, y + row * scale + dy, color);
                }
            }
        }
    }
}

void ss_glyph_draw_text(pixel_writer_t writer, void *ctx, int32_t x, int32_t y, int32_t scale,
                        const char *text, uint16_t color)
{
    int32_t cursor = x;

    if (writer == NULL || text == NULL) {
        return;
    }

    for (size_t i = 0; text[i] != '\0'; i++) {
        ss_glyph_draw_char(writer, ctx, cursor, y, scale, text[i], color);
        cursor += 6 * scale;
    }
}

bool ss_glyph_selftest(void)
{
    /* Known printable glyph resolves to a non-space (non-empty) bitmap. */
    const uint8_t *eight = ss_glyph_rows('8');
    bool eight_lit = false;
    for (int i = 0; i < 7; i++) {
        eight_lit |= (eight[i] != 0x00);
    }

    /* A box-drawing code resolves to its own (non-space) bitmap. */
    const uint8_t *pipe = ss_glyph_rows((char)SS_GLYPH_PIPE_V);
    bool pipe_lit = (pipe[0] == 0x04);

    /* A character not in the table falls back to the space glyph (all zero). */
    const uint8_t *missing = ss_glyph_rows('Q');
    bool miss_is_space = (missing == s_glyphs[0].rows);

    return eight_lit && pipe_lit && miss_is_space;
}
